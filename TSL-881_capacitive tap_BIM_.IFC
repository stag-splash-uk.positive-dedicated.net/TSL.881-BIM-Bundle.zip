Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: TSL881 BIM_BODIES ONLY_[A].IFC
Time: 2018-03-16T15:56:35
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 060076_SPIGOT
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 060247
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 060280
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: CACHE-TT-AERATOR 0.5GPM
In: Default Storey
PredefinedType: ELEMENT
